# Prepend the wpa-supplicant script to the initial config 

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"